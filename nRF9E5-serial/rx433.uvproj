# Keil uVision project rx433.uvproj, settings and files
target Target 1 (MCS-51)
  device: nRF9E5 Multiband Nordic Semiconductor
  cpu: IRAM(0-0xFF) CLOCK(33000000) MODDP2
  output: rx433 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: rx433.c
